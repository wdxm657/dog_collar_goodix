# Keil uVision project ble_app_chelsea_a_freertos.uvprojx, settings and files
target chelsea_a_exclusive (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: chelsea_a_os_exclusive +hex
  AfterMake: fromelf.exe --text -c --output Listings\@L.s   Objects\@L.axf
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ENV_USE_FREERTOS,CONFIG_L_EVK_T2_GH3038Q,CONFIG_CHEALSE_A,GOODIX_HR_ALGO_VERISON=4,GOODIX_SPO2_ALGO_VERISON=4
  c include: ..\Src\config;..\Src\platform;..\Src\user;..\Src\config;..\..\..\platform\gr5526_sdk\components\boards;..\..\..\platform\gr5526_sdk\components\drivers_ext\gr55xx;..\..\..\platform\gr5526_sdk\components\drivers_ext\st7735;..\..\..\platform\gr5526_sdk\components\drivers_ext\vs1005;..\..\..\platform\gr5526_sdk\components\libraries\app_alarm;..\..\..\platform\gr5526_sdk\components\libraries\app_assert;..\..\..\platform\gr5526_sdk\components\libraries\app_error;..\..\..\platform\gr5526_sdk\components\libraries\app_key;..\..\..\platform\gr5526_sdk\components\libraries\app_log;..\..\..\platform\gr5526_sdk\components\libraries\app_queue;..\..\..\platform\gr5526_sdk\components\libraries\app_timer;..\..\..\platform\gr5526_sdk\components\libraries\at_cmd;..\..\..\platform\gr5526_sdk\components\libraries\ble\ble_time;..\..\..\platform\gr5526_sdk\components\libraries\dfu_master;..\..\..\platform\gr5526_sdk\components\libraries\dfu_port;..\..\..\platform\gr5526_sdk\components\libraries\gui;..\..\..\platform\gr5526_sdk\components\libraries\gui\gui_config;..\..\..\platform\gr5526_sdk\components\libraries\hal_flash;..\..\..\platform\gr5526_sdk\components\libraries\hci_uart;..\..\..\platform\gr5526_sdk\components\libraries\pmu_calibration;..\..\..\platform\gr5526_sdk\components\libraries\ring_buffer;..\..\..\platform\gr5526_sdk\components\libraries\sensorsim;..\..\..\platform\gr5526_sdk\components\libraries\utility;..\..\..\platform\gr5526_sdk\components\patch\ind;..\..\..\platform\gr5526_sdk\components\profiles\ams_c;..\..\..\platform\gr5526_sdk\components\profiles\ancs_c;..\..\..\platform\gr5526_sdk\components\profiles\ans;..\..\..\platform\gr5526_sdk\components\profiles\ans_c;..\..\..\platform\gr5526_sdk\components\profiles\bas;..\..\..\platform\gr5526_sdk\components\profiles\bas_c;..\..\..\platform\gr5526_sdk\components\profiles\bcs;..\..\..\platform\gr5526_sdk\components\profiles\bps;..\..\..\platform\gr5526_sdk\components\profiles\common;..\..\..\platform\gr5526_sdk\components\profiles\cscs;..\..\..\platform\gr5526_sdk\components\profiles\cts;..\..\..\platform\gr5526_sdk\components\profiles\cts_c;..\..\..\platform\gr5526_sdk\components\profiles\dis;..\..\..\platform\gr5526_sdk\components\profiles\dis_c;..\..\..\platform\gr5526_sdk\components\profiles\gls;..\..\..\platform\gr5526_sdk\components\profiles\gus;..\..\..\platform\gr5526_sdk\components\profiles\gus_c;..\..\..\platform\gr5526_sdk\components\profiles\hids;..\..\..\platform\gr5526_sdk\components\profiles\hrrcps;..\..\..\platform\gr5526_sdk\components\profiles\hrs;..\..\..\platform\gr5526_sdk\components\profiles\hrs_c;..\..\..\platform\gr5526_sdk\components\profiles\hts;..\..\..\platform\gr5526_sdk\components\profiles\ias;..\..\..\platform\gr5526_sdk\components\profiles\lls;..\..\..\platform\gr5526_sdk\components\profiles\lms;..\..\..\platform\gr5526_sdk\components\profiles\ndcs;..\..\..\platform\gr5526_sdk\components\profiles\otas;..\..\..\platform\gr5526_sdk\components\profiles\otas_c;..\..\..\platform\gr5526_sdk\components\profiles\pass;..\..\..\platform\gr5526_sdk\components\profiles\pass_c;..\..\..\platform\gr5526_sdk\components\profiles\pcs;..\..\..\platform\gr5526_sdk\components\profiles\rscs;..\..\..\platform\gr5526_sdk\components\profiles\rscs_c;..\..\..\platform\gr5526_sdk\components\profiles\rtus;..\..\..\platform\gr5526_sdk\components\profiles\sample;..\..\..\platform\gr5526_sdk\components\profiles\ths;..\..\..\platform\gr5526_sdk\components\profiles\ths_c;..\..\..\platform\gr5526_sdk\components\profiles\thscps;..\..\..\platform\gr5526_sdk\components\profiles\tps;..\..\..\platform\gr5526_sdk\components\profiles\wechat;..\..\..\platform\gr5526_sdk\components\sdk\;..\..\..\platform\gr5526_sdk\drivers\inc;..\..\..\platform\gr5526_sdk\drivers\inc\hal;..\..\..\platform\gr5526_sdk\external\freertos\include;..\..\..\platform\gr5526_sdk\external\freertos\portable\RVDS\ARM_CM4F;..\..\..\platform\gr5526_sdk\external\segger_rtt;..\..\..\platform\gr5526_sdk\platform\arch\arm\cortex-m\cmsis\core\include;..\..\..\platform\boards;..\..\..\platform\gr5526_sdk\platform\include;..\..\..\platform\gr5526_sdk\platform\soc\include;..\..\..\platform\gr5526_sdk\platform\soc\linker\keil;..\Src\gh3036sdk;..\Src\gh3036sdk\config;..\Src\sensor\lis2dw12\inc;..\..\..\components\core_framework\inc;..\..\..\components\os_adapter\inc;..\..\..\components\os_adapter\os_impl\FreeRTOS\inc;..\..\..\components\os_adapter\os_impl\shared\inc;..\..\..\components\os_adapter\shared\inc;..\..\..\components\sensors\sensor\lis2dw12\driver;..\..\..\components\gh3036_sdk\gh_app\inc;..\..\..\components\gh3036_sdk\gh_hal\hw_interface\inc;..\..\..\components\gh3036_sdk\gh_hal\hw_service\inc;..\..\..\components\gh3036_sdk\gh_protocol;..\..\..\components\gh3036_sdk\gh_algo\adt;..\..\..\components\gh3036_sdk\gh_algo\common;..\..\..\components\gh3036_sdk\gh_algo\hr\exclusive;..\..\..\components\gh3036_sdk\gh_algo\hrv;..\..\..\components\gh3036_sdk\gh_algo\nadt;..\..\..\components\gh3036_sdk\gh_algo\spo2\premium;..\Src\profiles\health;..\Src\os_adapter\inc;..\..\..\platform\gr5526_sdk\components\libraries\app_graphics_mem;..\..\..\components\factory\inc
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x3000a000 size 0x36000
  scatter file: ..\..\..\platform\gr5526_sdk\platform\soc\linker\keil\flash_scatter_graphics.sct
  link misc: ..\..\..\platform\gr5526_sdk\platform\soc\linker\keil\rom_symbol.txt
  group gr_startup
    ../../../platform/gr5526_sdk/platform/arch/arm/cortex-m/keil/: Startup.S
  group gr_arch
    ../../../platform/gr5526_sdk/platform/soc/common/: gr_interrupt.c gr_platform.c gr_system.c
  group gr_soc
    ../../../platform/gr5526_sdk/platform/soc/src/: gr_soc.c
  group gr_board
    ../../../platform/boards/: board_SK.c
  group gr_stack_lib
    ../../../platform/gr5526_sdk/platform/soc/linker/keil/: ble_sdk.lib
  group gr_app_drivers
    ../../../platform/gr5526_sdk/drivers/src/: app_dma.c app_gpiote.c app_io.c app_pwr_mgmt.c app_uart.c app_rtos_cfg.c app_uart_dma.c app_rtc.c app_i2c.c app_i2c_dma.c app_spi.c app_spi_dma.c app_graphics_ospi.c
  group gr_libraries
    ../../../platform/gr5526_sdk/components/libraries/utility/: utility.c
    ../../../platform/gr5526_sdk/components/libraries/app_timer/: app_timer.c
    ../../../platform/gr5526_sdk/components/libraries/ring_buffer/: ring_buffer.c
    ../../../platform/gr5526_sdk/components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../platform/gr5526_sdk/components/libraries/app_log/: app_log.c app_log_dump_port.c app_log_store.c
    ../../../platform/gr5526_sdk/components/libraries/app_error/: app_error.c
    ../../../platform/gr5526_sdk/components/libraries/app_assert/: app_assert.c
    ../../../platform/gr5526_sdk/components/libraries/app_key/: app_key.c app_key_core.c
    ../../../platform/gr5526_sdk/components/libraries/ble/ble_time/: ble_time.c
    ../../../platform/gr5526_sdk/components/libraries/dfu_port/: dfu_port.c
    ../../../platform/gr5526_sdk/components/sdk/: ble.c
    ../../../platform/gr5526_sdk/components/libraries/app_graphics_mem/: app_graphics_mem.c
  group gr_profiles
    ../../../platform/gr5526_sdk/components/profiles/common/: ble_prf_utils.c
    ../../../platform/gr5526_sdk/components/profiles/otas/: otas.c
    ../../../platform/gr5526_sdk/components/profiles/lms/: lms.c
    ../Src/profiles/health/: health.c
    ../../../platform/gr5526_sdk/components/profiles/hrs/: hrs.c
  group external
    ../../../platform/gr5526_sdk/external/freertos/portable/GR55XX/: port_pm.c
    ../../../platform/gr5526_sdk/external/freertos/portable/RVDS/ARM_CM4F/: port.c
    ../../../platform/gr5526_sdk/external/freertos/: timers.c tasks.c stream_buffer.c queue.c list.c heap_4.c event_groups.c croutine.c
    ../../../platform/gr5526_sdk/external/segger_rtt/: SEGGER_RTT.c
  group user_platform
    ../Src/platform/: user_periph_setup.c
  group user_app
    ../Src/user/: main.c user_app.c FreeRTOSConfig.h
    ./../Src/config/: custom_config.h
  group chelsea/hal
    ../../../components/gh3036_sdk/gh_hal/hw_interface/src/: gh_hal_chip.c gh_hal_interface.c
    ../../../components/gh3036_sdk/gh_hal/hw_service/src/: gh_hal_agc.c gh_hal_agc_dre.c gh_hal_config_process.c gh_hal_control.c gh_hal_fifo_parser.c gh_hal_isr.c gh_hal_service.c gh_hal_settings.c gh_hal_std.c gh_hal_user.c gh_hal_utils.c gh_hal_efuse_read.c
    ../../../components/gh3036_sdk/gh_hal/hw_libs/: cortex-m4_keil-armcc-5.06_o2_gh3036drv.lib
  group chelsea/app
    ../../../components/gh3036_sdk/gh_app/src/: gh_app.c gh_app_mips.c gh_app_user.c gh_config_process.c gh_global_config.c gh_reg_config.c gh_sample_ctrl.c goodix_app_user.c
    ../../../components/gh3036_sdk/gh_app/src/app_fusion/: gh_data_sync_fusion.c gh_data_fusion.c
    ../../../components/gh3036_sdk/gh_app/src/app_manager/: gh_algo_adapter.c gh_algo_adt.c gh_algo_hr_third_party.c gh_algo_hrv_third_party.c gh_algo_mem.c gh_algo_nadt_third_party.c gh_algo_spo2_third_party.c gh_app_manager.c
    ../../../components/gh3036_sdk/gh_app/src/app_mtss/: gh_mtss_evt_manager.c
  group chelsea/protocol
    ../../../components/gh3036_sdk/gh_protocol/: gh_data_package.c gh_package.c gh_protocol_cmd.c gh_protocol_user.c gh_rpccore.c slabmemory.c staticmapimp.c
  group chelsea/algo/exclusive
    ../../../components/gh3036_sdk/gh_algo/adt/: gh_move_detector.c gh_wear_detector.c
    ../../../components/gh3036_sdk/gh_algo/common/: cortex-m4_keil-armcc-5.06_o2_common_dsp.lib
    ../../../components/gh3036_sdk/gh_algo/common/premium_exclusive/: cortex-m4_keil-armcc-5.06_o2_common_dl.lib
    ../../../components/gh3036_sdk/gh_algo/hr/exclusive/: cortex-m4_keil-armcc-5.06_o2_hr.lib goodix_hba_config.c HRNet_knBasicWeights.c HRNet_knConfNetWeights.c HRNet_knMultiWeights.c HRNet_knSceneNetWeights.c HRNet_knSceneSwitchWeights.c HRNet_knSmallWeights.c HRNet_knTdfusionWeights.c HRNet_knWeights.c
    ../../../components/gh3036_sdk/gh_algo/hrv/: cortex-m4_keil-armcc-5.06_o2_hrv.lib goodix_hrv_config.c
    ../../../components/gh3036_sdk/gh_algo/nadt/: cortex-m4_keil-armcc-5.06_o2_nadt.lib goodix_nadt_config.c
    ../../../components/gh3036_sdk/gh_algo/spo2/premium/: cortex-m4_keil-armcc-5.06_o2_spo2.lib goodix_spo2_config_for_gh3036_a43992.c goodix_spo2_net_for_gh3036_a43992.c
  group chelsea/algo/premium
    ../../../components/gh3036_sdk/gh_algo/adt/: gh_move_detector.c gh_wear_detector.c
    ../../../components/gh3036_sdk/gh_algo/common/premium_exclusive/: cortex-m4_keil-armcc-5.06_o2_common_dl.lib
    ../../../components/gh3036_sdk/gh_algo/common/: cortex-m4_keil-armcc-5.06_o2_common_dsp.lib
    ../../../components/gh3036_sdk/gh_algo/hr/premium/: cortex-m4_keil-armcc-5.06_o2_hr.lib goodix_hba_config.c HRNet_knBasicWeights.c HRNet_knConfNetWeights.c HRNet_knMultiWeights.c HRNet_knSceneNetWeights.c HRNet_knSceneSwitchWeights.c HRNet_knSmallWeights.c HRNet_knTdfusionWeights.c HRNet_knWeights.c
    ../../../components/gh3036_sdk/gh_algo/hrv/: cortex-m4_keil-armcc-5.06_o2_hrv.lib goodix_hrv_config.c
    ../../../components/gh3036_sdk/gh_algo/nadt/: cortex-m4_keil-armcc-5.06_o2_nadt.lib goodix_nadt_config.c
    ../../../components/gh3036_sdk/gh_algo/spo2/premium/: cortex-m4_keil-armcc-5.06_o2_spo2.lib goodix_spo2_config_for_gh3036_a43992.c goodix_spo2_net_for_gh3036_a43992.c
  group chelsea/algo/medium
    ../../../components/gh3036_sdk/gh_algo/adt/: gh_move_detector.c gh_wear_detector.c
    ../../../components/gh3036_sdk/gh_algo/common/basic_medium/: cortex-m4_keil-armcc-5.06_o2_common_dl.lib
    ../../../components/gh3036_sdk/gh_algo/common/: cortex-m4_keil-armcc-5.06_o2_common_dsp.lib
    ../../../components/gh3036_sdk/gh_algo/hr/medium/: cortex-m4_keil-armcc-5.06_o2_hr.lib goodix_hba_config.c HRNet_knBasicWeights.c HRNet_knConfNetWeights.c HRNet_knMultiWeights.c HRNet_knSceneNetWeights.c HRNet_knSceneSwitchWeights.c HRNet_knSmallWeights.c HRNet_knWeights.c
    ../../../components/gh3036_sdk/gh_algo/hrv/: cortex-m4_keil-armcc-5.06_o2_hrv.lib goodix_hrv_config.c
    ../../../components/gh3036_sdk/gh_algo/nadt/: cortex-m4_keil-armcc-5.06_o2_nadt.lib goodix_nadt_config.c
    ../../../components/gh3036_sdk/gh_algo/spo2/basic/: cortex-m4_keil-armcc-5.06_o2_spo2.lib goodix_spo2_config_for_gh3036_a43992.c goodix_spo2_net_for_gh3036_a43992.c
  group chelsea/algo/basic
    ../../../components/gh3036_sdk/gh_algo/adt/: gh_move_detector.c gh_wear_detector.c
    ../../../components/gh3036_sdk/gh_algo/common/: cortex-m4_keil-armcc-5.06_o2_common_dsp.lib
    ../../../components/gh3036_sdk/gh_algo/common/basic_medium/: cortex-m4_keil-armcc-5.06_o2_common_dl.lib
    ../../../components/gh3036_sdk/gh_algo/hr/basic/: cortex-m4_keil-armcc-5.06_o2_hr.lib goodix_hba_config.c HRNet_knBasicWeights.c HRNet_knConfNetWeights.c HRNet_knMultiWeights.c HRNet_knSceneNetWeights.c HRNet_knSceneSwitchWeights.c HRNet_knSmallWeights.c HRNet_knTdfusionWeights.c HRNet_knWeights.c
    ../../../components/gh3036_sdk/gh_algo/hrv/: cortex-m4_keil-armcc-5.06_o2_hrv.lib goodix_hrv_config.c
    ../../../components/gh3036_sdk/gh_algo/nadt/: cortex-m4_keil-armcc-5.06_o2_nadt.lib goodix_nadt_config.c
    ../../../components/gh3036_sdk/gh_algo/spo2/basic/: cortex-m4_keil-armcc-5.06_o2_spo2.lib goodix_spo2_config_for_gh3036_a43992.c goodix_spo2_net_for_gh3036_a43992.c
  group chelsea/user
    ../Src/gh3036sdk/config/: gh_global_config.h gh_hal_config.h
    ../Src/gh3036sdk/: gh_app_user_for_gr5526.c gh_demo.c gh_gsensor_bridge.c gh_hal_user_for_gr5526.c gh_protocol_user_for_gr5526.c gh_reg_lists.c
    ../Src/gh3036sdk/gh_hal/: gh_hal_interface.c gh_hal_chip.c
  group app/thread
    ../../../components/core_framework/src/: app_thread.c app_thread_health.c app_thread_imu.c app_thread_phas.c app_thread_factory.c
  group app/mqueue
    ../../../components/core_framework/src/: app_mqueue.c app_mqueue_health.c app_mqueue_imu.c app_mqueue_phas.c
  group app/fifo
    ../../../components/core_framework/src/: app_imu_fifo.c
  group osal/waper
    ../../../components/os_adapter/shared/src/: osal_heap.c osal_mutex.c osal_queue.c osal_ringbuf.c osal_sema.c osal_task.c osal_timer.c
    ../Src/os_adapter/src/: osal_event.c osal_priority_queue.c osal_psram.c
  group osal/impl
    ../../../components/os_adapter/os_impl/FreeRTOS/src/: os_impl_heap.c os_impl_mutex.c os_impl_queue.c os_impl_sema.c os_impl_task.c os_impl_timer.c
    ../../../components/os_adapter/os_impl/shared/src/: os_impl_ringbuf.c
  group gsensor/lis2dw12
    ../../../components/sensors/sensor/lis2dw12/driver/: lis2dw12_reg.c
    ../Src/sensor/lis2dw12/: lis2dw12.c
  group factory
    ../../../components/factory/src/: factory.c
    ../../../components/factory/src/utils/: factory_ctr.c factory_hpf.c factory_noise.c
target chelsea_a_premium (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: chelsea_a_os_premium +hex
  AfterMake: as above
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ENV_USE_FREERTOS,CONFIG_L_EVK_T2_GH3038Q,CONFIG_CHEALSE_A,GOODIX_HR_ALGO_VERISON=3,GOODIX_SPO2_ALGO_VERISON=3
  c include: ..\Src\config;..\Src\platform;..\Src\user;..\Src\config;..\..\..\platform\gr5526_sdk\components\boards;..\..\..\platform\gr5526_sdk\components\drivers_ext\gr55xx;..\..\..\platform\gr5526_sdk\components\drivers_ext\st7735;..\..\..\platform\gr5526_sdk\components\drivers_ext\vs1005;..\..\..\platform\gr5526_sdk\components\libraries\app_alarm;..\..\..\platform\gr5526_sdk\components\libraries\app_assert;..\..\..\platform\gr5526_sdk\components\libraries\app_error;..\..\..\platform\gr5526_sdk\components\libraries\app_key;..\..\..\platform\gr5526_sdk\components\libraries\app_log;..\..\..\platform\gr5526_sdk\components\libraries\app_queue;..\..\..\platform\gr5526_sdk\components\libraries\app_timer;..\..\..\platform\gr5526_sdk\components\libraries\at_cmd;..\..\..\platform\gr5526_sdk\components\libraries\ble\ble_time;..\..\..\platform\gr5526_sdk\components\libraries\dfu_master;..\..\..\platform\gr5526_sdk\components\libraries\dfu_port;..\..\..\platform\gr5526_sdk\components\libraries\gui;..\..\..\platform\gr5526_sdk\components\libraries\gui\gui_config;..\..\..\platform\gr5526_sdk\components\libraries\hal_flash;..\..\..\platform\gr5526_sdk\components\libraries\hci_uart;..\..\..\platform\gr5526_sdk\components\libraries\pmu_calibration;..\..\..\platform\gr5526_sdk\components\libraries\ring_buffer;..\..\..\platform\gr5526_sdk\components\libraries\sensorsim;..\..\..\platform\gr5526_sdk\components\libraries\utility;..\..\..\platform\gr5526_sdk\components\patch\ind;..\..\..\platform\gr5526_sdk\components\profiles\ams_c;..\..\..\platform\gr5526_sdk\components\profiles\ancs_c;..\..\..\platform\gr5526_sdk\components\profiles\ans;..\..\..\platform\gr5526_sdk\components\profiles\ans_c;..\..\..\platform\gr5526_sdk\components\profiles\bas;..\..\..\platform\gr5526_sdk\components\profiles\bas_c;..\..\..\platform\gr5526_sdk\components\profiles\bcs;..\..\..\platform\gr5526_sdk\components\profiles\bps;..\..\..\platform\gr5526_sdk\components\profiles\common;..\..\..\platform\gr5526_sdk\components\profiles\cscs;..\..\..\platform\gr5526_sdk\components\profiles\cts;..\..\..\platform\gr5526_sdk\components\profiles\cts_c;..\..\..\platform\gr5526_sdk\components\profiles\dis;..\..\..\platform\gr5526_sdk\components\profiles\dis_c;..\..\..\platform\gr5526_sdk\components\profiles\gls;..\..\..\platform\gr5526_sdk\components\profiles\gus;..\..\..\platform\gr5526_sdk\components\profiles\gus_c;..\..\..\platform\gr5526_sdk\components\profiles\hids;..\..\..\platform\gr5526_sdk\components\profiles\hrrcps;..\..\..\platform\gr5526_sdk\components\profiles\hrs;..\..\..\platform\gr5526_sdk\components\profiles\hrs_c;..\..\..\platform\gr5526_sdk\components\profiles\hts;..\..\..\platform\gr5526_sdk\components\profiles\ias;..\..\..\platform\gr5526_sdk\components\profiles\lls;..\..\..\platform\gr5526_sdk\components\profiles\lms;..\..\..\platform\gr5526_sdk\components\profiles\ndcs;..\..\..\platform\gr5526_sdk\components\profiles\otas;..\..\..\platform\gr5526_sdk\components\profiles\otas_c;..\..\..\platform\gr5526_sdk\components\profiles\pass;..\..\..\platform\gr5526_sdk\components\profiles\pass_c;..\..\..\platform\gr5526_sdk\components\profiles\pcs;..\..\..\platform\gr5526_sdk\components\profiles\rscs;..\..\..\platform\gr5526_sdk\components\profiles\rscs_c;..\..\..\platform\gr5526_sdk\components\profiles\rtus;..\..\..\platform\gr5526_sdk\components\profiles\sample;..\..\..\platform\gr5526_sdk\components\profiles\ths;..\..\..\platform\gr5526_sdk\components\profiles\ths_c;..\..\..\platform\gr5526_sdk\components\profiles\thscps;..\..\..\platform\gr5526_sdk\components\profiles\tps;..\..\..\platform\gr5526_sdk\components\profiles\wechat;..\..\..\platform\gr5526_sdk\components\sdk\;..\..\..\platform\gr5526_sdk\drivers\inc;..\..\..\platform\gr5526_sdk\drivers\inc\hal;..\..\..\platform\gr5526_sdk\external\freertos\include;..\..\..\platform\gr5526_sdk\external\freertos\portable\RVDS\ARM_CM4F;..\..\..\platform\gr5526_sdk\external\segger_rtt;..\..\..\platform\gr5526_sdk\platform\arch\arm\cortex-m\cmsis\core\include;..\..\..\platform\boards;..\..\..\platform\gr5526_sdk\platform\include;..\..\..\platform\gr5526_sdk\platform\soc\include;..\..\..\platform\gr5526_sdk\platform\soc\linker\keil;..\Src\gh3036sdk;..\Src\gh3036sdk\config;..\Src\sensor\lis2dw12\inc;..\..\..\components\core_framework\inc;..\..\..\components\os_adapter\inc;..\..\..\components\os_adapter\os_impl\FreeRTOS\inc;..\..\..\components\os_adapter\os_impl\shared\inc;..\..\..\components\os_adapter\shared\inc;..\..\..\components\sensors\sensor\lis2dw12\driver;..\..\..\components\gh3036_sdk\gh_app\inc;..\..\..\components\gh3036_sdk\gh_hal\hw_interface\inc;..\..\..\components\gh3036_sdk\gh_hal\hw_service\inc;..\..\..\components\gh3036_sdk\gh_protocol;..\..\..\components\gh3036_sdk\gh_algo\adt;..\..\..\components\gh3036_sdk\gh_algo\common;..\..\..\components\gh3036_sdk\gh_algo\hr\premium;..\..\..\components\gh3036_sdk\gh_algo\hrv;..\..\..\components\gh3036_sdk\gh_algo\nadt;..\..\..\components\gh3036_sdk\gh_algo\spo2\premium;..\Src\profiles\health
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x3000a000 size 0x36000
  scatter file: ..\..\..\platform\gr5526_sdk\platform\soc\linker\keil\flash_scatter_common.sct
  link misc: as above
target chelsea_a_medium (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: chelsea_a_os_medium +hex
  AfterMake: as above
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ENV_USE_FREERTOS,CONFIG_L_EVK_T2_GH3038Q,CONFIG_CHEALSE_A,GOODIX_HR_ALGO_VERISON=2,GOODIX_SPO2_ALGO_VERISON=2
  c include: ..\Src\config;..\Src\platform;..\Src\user;..\Src\config;..\..\..\platform\gr5526_sdk\components\boards;..\..\..\platform\gr5526_sdk\components\drivers_ext\gr55xx;..\..\..\platform\gr5526_sdk\components\drivers_ext\st7735;..\..\..\platform\gr5526_sdk\components\drivers_ext\vs1005;..\..\..\platform\gr5526_sdk\components\libraries\app_alarm;..\..\..\platform\gr5526_sdk\components\libraries\app_assert;..\..\..\platform\gr5526_sdk\components\libraries\app_error;..\..\..\platform\gr5526_sdk\components\libraries\app_key;..\..\..\platform\gr5526_sdk\components\libraries\app_log;..\..\..\platform\gr5526_sdk\components\libraries\app_queue;..\..\..\platform\gr5526_sdk\components\libraries\app_timer;..\..\..\platform\gr5526_sdk\components\libraries\at_cmd;..\..\..\platform\gr5526_sdk\components\libraries\ble\ble_time;..\..\..\platform\gr5526_sdk\components\libraries\dfu_master;..\..\..\platform\gr5526_sdk\components\libraries\dfu_port;..\..\..\platform\gr5526_sdk\components\libraries\gui;..\..\..\platform\gr5526_sdk\components\libraries\gui\gui_config;..\..\..\platform\gr5526_sdk\components\libraries\hal_flash;..\..\..\platform\gr5526_sdk\components\libraries\hci_uart;..\..\..\platform\gr5526_sdk\components\libraries\pmu_calibration;..\..\..\platform\gr5526_sdk\components\libraries\ring_buffer;..\..\..\platform\gr5526_sdk\components\libraries\sensorsim;..\..\..\platform\gr5526_sdk\components\libraries\utility;..\..\..\platform\gr5526_sdk\components\patch\ind;..\..\..\platform\gr5526_sdk\components\profiles\ams_c;..\..\..\platform\gr5526_sdk\components\profiles\ancs_c;..\..\..\platform\gr5526_sdk\components\profiles\ans;..\..\..\platform\gr5526_sdk\components\profiles\ans_c;..\..\..\platform\gr5526_sdk\components\profiles\bas;..\..\..\platform\gr5526_sdk\components\profiles\bas_c;..\..\..\platform\gr5526_sdk\components\profiles\bcs;..\..\..\platform\gr5526_sdk\components\profiles\bps;..\..\..\platform\gr5526_sdk\components\profiles\common;..\..\..\platform\gr5526_sdk\components\profiles\cscs;..\..\..\platform\gr5526_sdk\components\profiles\cts;..\..\..\platform\gr5526_sdk\components\profiles\cts_c;..\..\..\platform\gr5526_sdk\components\profiles\dis;..\..\..\platform\gr5526_sdk\components\profiles\dis_c;..\..\..\platform\gr5526_sdk\components\profiles\gls;..\..\..\platform\gr5526_sdk\components\profiles\gus;..\..\..\platform\gr5526_sdk\components\profiles\gus_c;..\..\..\platform\gr5526_sdk\components\profiles\hids;..\..\..\platform\gr5526_sdk\components\profiles\hrrcps;..\..\..\platform\gr5526_sdk\components\profiles\hrs;..\..\..\platform\gr5526_sdk\components\profiles\hrs_c;..\..\..\platform\gr5526_sdk\components\profiles\hts;..\..\..\platform\gr5526_sdk\components\profiles\ias;..\..\..\platform\gr5526_sdk\components\profiles\lls;..\..\..\platform\gr5526_sdk\components\profiles\lms;..\..\..\platform\gr5526_sdk\components\profiles\ndcs;..\..\..\platform\gr5526_sdk\components\profiles\otas;..\..\..\platform\gr5526_sdk\components\profiles\otas_c;..\..\..\platform\gr5526_sdk\components\profiles\pass;..\..\..\platform\gr5526_sdk\components\profiles\pass_c;..\..\..\platform\gr5526_sdk\components\profiles\pcs;..\..\..\platform\gr5526_sdk\components\profiles\rscs;..\..\..\platform\gr5526_sdk\components\profiles\rscs_c;..\..\..\platform\gr5526_sdk\components\profiles\rtus;..\..\..\platform\gr5526_sdk\components\profiles\sample;..\..\..\platform\gr5526_sdk\components\profiles\ths;..\..\..\platform\gr5526_sdk\components\profiles\ths_c;..\..\..\platform\gr5526_sdk\components\profiles\thscps;..\..\..\platform\gr5526_sdk\components\profiles\tps;..\..\..\platform\gr5526_sdk\components\profiles\wechat;..\..\..\platform\gr5526_sdk\components\sdk\;..\..\..\platform\gr5526_sdk\drivers\inc;..\..\..\platform\gr5526_sdk\drivers\inc\hal;..\..\..\platform\gr5526_sdk\external\freertos\include;..\..\..\platform\gr5526_sdk\external\freertos\portable\RVDS\ARM_CM4F;..\..\..\platform\gr5526_sdk\external\segger_rtt;..\..\..\platform\gr5526_sdk\platform\arch\arm\cortex-m\cmsis\core\include;..\..\..\platform\boards;..\..\..\platform\gr5526_sdk\platform\include;..\..\..\platform\gr5526_sdk\platform\soc\include;..\..\..\platform\gr5526_sdk\platform\soc\linker\keil;..\Src\gh3036sdk;..\Src\gh3036sdk\config;..\Src\sensor\lis2dw12\inc;..\..\..\components\core_framework\inc;..\..\..\components\os_adapter\inc;..\..\..\components\os_adapter\os_impl\FreeRTOS\inc;..\..\..\components\os_adapter\os_impl\shared\inc;..\..\..\components\os_adapter\shared\inc;..\..\..\components\sensors\sensor\lis2dw12\driver;..\..\..\components\gh3036_sdk\gh_app\inc;..\..\..\components\gh3036_sdk\gh_hal\hw_interface\inc;..\..\..\components\gh3036_sdk\gh_hal\hw_service\inc;..\..\..\components\gh3036_sdk\gh_protocol;..\..\..\components\gh3036_sdk\gh_algo\adt;..\..\..\components\gh3036_sdk\gh_algo\common;..\..\..\components\gh3036_sdk\gh_algo\hr\medium;..\..\..\components\gh3036_sdk\gh_algo\hrv;..\..\..\components\gh3036_sdk\gh_algo\nadt;..\..\..\components\gh3036_sdk\gh_algo\spo2\basic;..\Src\profiles\health
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x3000a000 size 0x36000
  scatter file: as above
  link misc: as above
target chelsea_a_basic (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: chelsea_a_os_basic +hex
  AfterMake: as above
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ENV_USE_FREERTOS,CONFIG_L_EVK_T2_GH3038Q,CONFIG_CHEALSE_A,GOODIX_HR_ALGO_VERISON=1,GOODIX_SPO2_ALGO_VERISON=1
  c include: ..\Src\config;..\Src\platform;..\Src\user;..\Src\config;..\..\..\platform\gr5526_sdk\components\boards;..\..\..\platform\gr5526_sdk\components\drivers_ext\gr55xx;..\..\..\platform\gr5526_sdk\components\drivers_ext\st7735;..\..\..\platform\gr5526_sdk\components\drivers_ext\vs1005;..\..\..\platform\gr5526_sdk\components\libraries\app_alarm;..\..\..\platform\gr5526_sdk\components\libraries\app_assert;..\..\..\platform\gr5526_sdk\components\libraries\app_error;..\..\..\platform\gr5526_sdk\components\libraries\app_key;..\..\..\platform\gr5526_sdk\components\libraries\app_log;..\..\..\platform\gr5526_sdk\components\libraries\app_queue;..\..\..\platform\gr5526_sdk\components\libraries\app_timer;..\..\..\platform\gr5526_sdk\components\libraries\at_cmd;..\..\..\platform\gr5526_sdk\components\libraries\ble\ble_time;..\..\..\platform\gr5526_sdk\components\libraries\dfu_master;..\..\..\platform\gr5526_sdk\components\libraries\dfu_port;..\..\..\platform\gr5526_sdk\components\libraries\gui;..\..\..\platform\gr5526_sdk\components\libraries\gui\gui_config;..\..\..\platform\gr5526_sdk\components\libraries\hal_flash;..\..\..\platform\gr5526_sdk\components\libraries\hci_uart;..\..\..\platform\gr5526_sdk\components\libraries\pmu_calibration;..\..\..\platform\gr5526_sdk\components\libraries\ring_buffer;..\..\..\platform\gr5526_sdk\components\libraries\sensorsim;..\..\..\platform\gr5526_sdk\components\libraries\utility;..\..\..\platform\gr5526_sdk\components\patch\ind;..\..\..\platform\gr5526_sdk\components\profiles\ams_c;..\..\..\platform\gr5526_sdk\components\profiles\ancs_c;..\..\..\platform\gr5526_sdk\components\profiles\ans;..\..\..\platform\gr5526_sdk\components\profiles\ans_c;..\..\..\platform\gr5526_sdk\components\profiles\bas;..\..\..\platform\gr5526_sdk\components\profiles\bas_c;..\..\..\platform\gr5526_sdk\components\profiles\bcs;..\..\..\platform\gr5526_sdk\components\profiles\bps;..\..\..\platform\gr5526_sdk\components\profiles\common;..\..\..\platform\gr5526_sdk\components\profiles\cscs;..\..\..\platform\gr5526_sdk\components\profiles\cts;..\..\..\platform\gr5526_sdk\components\profiles\cts_c;..\..\..\platform\gr5526_sdk\components\profiles\dis;..\..\..\platform\gr5526_sdk\components\profiles\dis_c;..\..\..\platform\gr5526_sdk\components\profiles\gls;..\..\..\platform\gr5526_sdk\components\profiles\gus;..\..\..\platform\gr5526_sdk\components\profiles\gus_c;..\..\..\platform\gr5526_sdk\components\profiles\hids;..\..\..\platform\gr5526_sdk\components\profiles\hrrcps;..\..\..\platform\gr5526_sdk\components\profiles\hrs;..\..\..\platform\gr5526_sdk\components\profiles\hrs_c;..\..\..\platform\gr5526_sdk\components\profiles\hts;..\..\..\platform\gr5526_sdk\components\profiles\ias;..\..\..\platform\gr5526_sdk\components\profiles\lls;..\..\..\platform\gr5526_sdk\components\profiles\lms;..\..\..\platform\gr5526_sdk\components\profiles\ndcs;..\..\..\platform\gr5526_sdk\components\profiles\otas;..\..\..\platform\gr5526_sdk\components\profiles\otas_c;..\..\..\platform\gr5526_sdk\components\profiles\pass;..\..\..\platform\gr5526_sdk\components\profiles\pass_c;..\..\..\platform\gr5526_sdk\components\profiles\pcs;..\..\..\platform\gr5526_sdk\components\profiles\rscs;..\..\..\platform\gr5526_sdk\components\profiles\rscs_c;..\..\..\platform\gr5526_sdk\components\profiles\rtus;..\..\..\platform\gr5526_sdk\components\profiles\sample;..\..\..\platform\gr5526_sdk\components\profiles\ths;..\..\..\platform\gr5526_sdk\components\profiles\ths_c;..\..\..\platform\gr5526_sdk\components\profiles\thscps;..\..\..\platform\gr5526_sdk\components\profiles\tps;..\..\..\platform\gr5526_sdk\components\profiles\wechat;..\..\..\platform\gr5526_sdk\components\sdk\;..\..\..\platform\gr5526_sdk\drivers\inc;..\..\..\platform\gr5526_sdk\drivers\inc\hal;..\..\..\platform\gr5526_sdk\external\freertos\include;..\..\..\platform\gr5526_sdk\external\freertos\portable\RVDS\ARM_CM4F;..\..\..\platform\gr5526_sdk\external\segger_rtt;..\..\..\platform\gr5526_sdk\platform\arch\arm\cortex-m\cmsis\core\include;..\..\..\platform\boards;..\..\..\platform\gr5526_sdk\platform\include;..\..\..\platform\gr5526_sdk\platform\soc\include;..\..\..\platform\gr5526_sdk\platform\soc\linker\keil;..\Src\gh3036sdk;..\Src\gh3036sdk\config;..\Src\sensor\lis2dw12\inc;..\..\..\components\core_framework\inc;..\..\..\components\os_adapter\inc;..\..\..\components\os_adapter\os_impl\FreeRTOS\inc;..\..\..\components\os_adapter\os_impl\shared\inc;..\..\..\components\os_adapter\shared\inc;..\..\..\components\sensors\sensor\lis2dw12\driver;..\..\..\components\gh3036_sdk\gh_app\inc;..\..\..\components\gh3036_sdk\gh_hal\hw_interface\inc;..\..\..\components\gh3036_sdk\gh_hal\hw_service\inc;..\..\..\components\gh3036_sdk\gh_protocol;..\..\..\components\gh3036_sdk\gh_algo\adt;..\..\..\components\gh3036_sdk\gh_algo\common;..\..\..\components\gh3036_sdk\gh_algo\hr\basic;..\..\..\components\gh3036_sdk\gh_algo\hrv;..\..\..\components\gh3036_sdk\gh_algo\nadt;..\..\..\components\gh3036_sdk\gh_algo\spo2\basic;..\Src\profiles\health
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x3000a000 size 0x36000
  scatter file: as above
  link misc: as above
