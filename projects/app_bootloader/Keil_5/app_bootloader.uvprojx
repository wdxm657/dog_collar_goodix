# Keil uVision project app_bootloader.uvprojx, settings and files
target GRxx_Soc (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app_bootloader +hex
  AfterMake: fromelf.exe --text -c --output Listings\@L.s   Objects\@L.axf
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOOTLOADER_ENABLE
  c include: ..\Src\config;..\Src\platform;..\Src\user;..\Src\config;..\..\..\platform\gr5526_sdk\components\app_drivers\inc;..\..\..\platform\gr5526_sdk\components\boards;..\..\..\platform\gr5526_sdk\components\drivers_ext\gr55xx;..\..\..\platform\gr5526_sdk\components\libraries\app_alarm;..\..\..\platform\gr5526_sdk\components\libraries\app_assert;..\..\..\platform\gr5526_sdk\components\libraries\app_error;..\..\..\platform\gr5526_sdk\components\libraries\app_key;..\..\..\platform\gr5526_sdk\components\libraries\app_log;..\..\..\platform\gr5526_sdk\components\libraries\app_queue;..\..\..\platform\gr5526_sdk\components\libraries\app_timer;..\..\..\platform\gr5526_sdk\components\libraries\at_cmd;..\..\..\platform\gr5526_sdk\components\libraries\bsp;..\..\..\platform\gr5526_sdk\components\libraries\dfu_master;..\..\..\platform\gr5526_sdk\components\libraries\gui;..\..\..\platform\gr5526_sdk\components\libraries\gui\gui_config;..\..\..\platform\gr5526_sdk\components\libraries\hal_flash;..\..\..\platform\gr5526_sdk\components\libraries\hci_uart;..\..\..\platform\gr5526_sdk\components\libraries\pmu_calibration;..\..\..\platform\gr5526_sdk\components\libraries\ring_buffer;..\..\..\platform\gr5526_sdk\components\libraries\sensorsim;..\..\..\platform\gr5526_sdk\components\libraries\utility;..\..\..\platform\gr5526_sdk\components\libraries\dfu_port;..\..\..\platform\gr5526_sdk\components\patch\ind;..\..\..\platform\gr5526_sdk\components\profiles\ams_c;..\..\..\platform\gr5526_sdk\components\profiles\ancs_c;..\..\..\platform\gr5526_sdk\components\profiles\ans;..\..\..\platform\gr5526_sdk\components\profiles\ans_c;..\..\..\platform\gr5526_sdk\components\profiles\bas;..\..\..\platform\gr5526_sdk\components\profiles\bas_c;..\..\..\platform\gr5526_sdk\components\profiles\bcs;..\..\..\platform\gr5526_sdk\components\profiles\bps;..\..\..\platform\gr5526_sdk\components\profiles\common;..\..\..\platform\gr5526_sdk\components\profiles\cscs;..\..\..\platform\gr5526_sdk\components\profiles\cts;..\..\..\platform\gr5526_sdk\components\profiles\cts_c;..\..\..\platform\gr5526_sdk\components\profiles\dis;..\..\..\platform\gr5526_sdk\components\profiles\dis_c;..\..\..\platform\gr5526_sdk\components\profiles\gls;..\..\..\platform\gr5526_sdk\components\profiles\gus;..\..\..\platform\gr5526_sdk\components\profiles\gus_c;..\..\..\platform\gr5526_sdk\components\profiles\hids;..\..\..\platform\gr5526_sdk\components\profiles\hrrcps;..\..\..\platform\gr5526_sdk\components\profiles\hrs;..\..\..\platform\gr5526_sdk\components\profiles\hrs_c;..\..\..\platform\gr5526_sdk\components\profiles\hts;..\..\..\platform\gr5526_sdk\components\profiles\ias;..\..\..\platform\gr5526_sdk\components\profiles\lls;..\..\..\platform\gr5526_sdk\components\profiles\ndcs;..\..\..\platform\gr5526_sdk\components\profiles\otas_c;..\..\..\platform\gr5526_sdk\components\profiles\pass;..\..\..\platform\gr5526_sdk\components\profiles\pass_c;..\..\..\platform\gr5526_sdk\components\profiles\pcs;..\..\..\platform\gr5526_sdk\components\profiles\rscs;..\..\..\platform\gr5526_sdk\components\profiles\rscs_c;..\..\..\platform\gr5526_sdk\components\profiles\rtus;..\..\..\platform\gr5526_sdk\components\profiles\sample;..\..\..\platform\gr5526_sdk\components\profiles\ths;..\..\..\platform\gr5526_sdk\components\profiles\ths_c;..\..\..\platform\gr5526_sdk\components\profiles\thscps;..\..\..\platform\gr5526_sdk\components\profiles\tps;..\..\..\platform\gr5526_sdk\components\profiles\wechat;..\..\..\platform\gr5526_sdk\components\profiles\otas;..\..\..\platform\gr5526_sdk\components\sdk\;..\..\..\platform\gr5526_sdk\components\libraries\app_crypto;..\..\..\platform\gr5526_sdk\components\drivers_ext\qspi_device;..\..\..\platform\gr5526_sdk\components\graphics\lvgl_port\drv_adapter;..\..\..\platform\gr5526_sdk\drivers\inc;..\..\..\platform\gr5526_sdk\drivers\inc\hal;..\..\..\platform\gr5526_sdk\external\freertos\include;..\..\..\platform\gr5526_sdk\external\segger_rtt;..\..\..\platform\gr5526_sdk\platform\arch\arm\cortex-m\cmsis\core\include;..\..\..\platform\boards;..\..\..\platform\gr5526_sdk\platform\include;..\..\..\platform\gr5526_sdk\platform\soc\include;..\..\..\platform\gr5526_sdk\platform\soc\linker\keil;..\Src\sign_verify\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\platform\gr5526_sdk\platform\soc\linker\keil\flash_scatter_common.sct
  link misc: ..\..\..\platform\gr5526_sdk\platform\soc\linker\keil\rom_symbol.txt
  group gr_startup
    ../../../platform/gr5526_sdk/platform/arch/arm/cortex-m/keil/: Startup.S
  group gr_arch
    ../../../platform/gr5526_sdk/platform/soc/common/: gr_system.c gr_interrupt.c gr_platform.c
  group gr_soc
    ../../../platform/gr5526_sdk/platform/soc/src/: gr_soc.c
  group gr_board
    ../../../platform/boards/: board_SK.c
  group gr_stack_lib
    ../../../platform/gr5526_sdk/platform/soc/linker/keil/: ble_sdk.lib
  group gr_app_drivers
    ../../../platform/gr5526_sdk/drivers/src/: app_dma.c app_io.c app_gpiote.c app_pwr_mgmt.c app_uart.c app_qspi.c app_qspi_dma.c app_spi.c app_spi_dma.c app_graphics_qspi.c
  group gr_libraries
    ../../../platform/gr5526_sdk/components/libraries/app_assert/: app_assert.c
    ../../../platform/gr5526_sdk/components/libraries/app_key/: app_key.c app_key_core.c
    ../../../platform/gr5526_sdk/components/libraries/app_log/: app_log.c
    ../../../platform/gr5526_sdk/components/libraries/app_timer/: app_timer.c
    ../../../platform/gr5526_sdk/components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../platform/gr5526_sdk/components/libraries/ring_buffer/: ring_buffer.c
    ../../../platform/gr5526_sdk/components/libraries/utility/: utility.c
    ../../../platform/gr5526_sdk/components/libraries/dfu_port/: dfu_port.c
    ../../../platform/gr5526_sdk/components/sdk/: ble.c
  group gr_crypto
    ../../../platform/gr5526_sdk/components/libraries/app_crypto/keil/: app_crypto.lib
  group gr_profiles
    ../../../platform/gr5526_sdk/components/profiles/common/: ble_prf_utils.c
    ../../../platform/gr5526_sdk/components/profiles/otas/: otas.c
  group gr_drivers_ext
    ../../../platform/gr5526_sdk/components/drivers_ext/gr55xx/: gr55xx_spi_flash.c
  group user_platform
    ../Src/platform/: user_periph_setup.c
  group user_security
    ../Src/sign_verify/src/: rsa.c pkc.c sign_verify.c
  group user_app
    ../Src/user/: main.c bootloader_ota.c bootloader_boot_vendor.c bootloader_boot_port.c
    ../Src/config/: bootloader_config.h custom_config.h
  group gr_drivers_ext_flash
    ../../../platform/gr5526_sdk/components/drivers_ext/qspi_device/: qspi_norflash_v2.c qspi_norflash_v2.h
    ../../../platform/gr5526_sdk/components/graphics/lvgl_port/drv_adapter/: drv_adapter_norflash.c drv_adapter_norflash.h drv_adapter_port.h drv_adapter_port_norflash.c
