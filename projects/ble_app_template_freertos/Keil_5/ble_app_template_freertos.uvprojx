# Keil uVision project ble_app_template_freertos.uvprojx, settings and files
target GRxx_Soc (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: ble_app_template_freertos +hex
  AfterMake: fromelf.exe --text -c --output Listings\@L.s   Objects\@L.axf
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ENV_USE_FREERTOS
  c include: ..\Src\config;..\Src\platform;..\Src\user;..\Src\config;..\..\..\platform\gr5526_sdk\components\boards;..\..\..\platform\gr5526_sdk\components\drivers_ext\gr55xx;..\..\..\platform\gr5526_sdk\components\drivers_ext\st7735;..\..\..\platform\gr5526_sdk\components\drivers_ext\vs1005;..\..\..\platform\gr5526_sdk\components\libraries\app_alarm;..\..\..\platform\gr5526_sdk\components\libraries\app_assert;..\..\..\platform\gr5526_sdk\components\libraries\app_error;..\..\..\platform\gr5526_sdk\components\libraries\app_key;..\..\..\platform\gr5526_sdk\components\libraries\app_log;..\..\..\platform\gr5526_sdk\components\libraries\app_queue;..\..\..\platform\gr5526_sdk\components\libraries\app_timer;..\..\..\platform\gr5526_sdk\components\libraries\at_cmd;..\..\..\platform\gr5526_sdk\components\libraries\ble\ble_time;..\..\..\platform\gr5526_sdk\components\libraries\dfu_master;..\..\..\platform\gr5526_sdk\components\libraries\dfu_port;..\..\..\platform\gr5526_sdk\components\libraries\gui;..\..\..\platform\gr5526_sdk\components\libraries\gui\gui_config;..\..\..\platform\gr5526_sdk\components\libraries\hal_flash;..\..\..\platform\gr5526_sdk\components\libraries\hci_uart;..\..\..\platform\gr5526_sdk\components\libraries\pmu_calibration;..\..\..\platform\gr5526_sdk\components\libraries\ring_buffer;..\..\..\platform\gr5526_sdk\components\libraries\sensorsim;..\..\..\platform\gr5526_sdk\components\libraries\utility;..\..\..\platform\gr5526_sdk\components\patch\ind;..\..\..\platform\gr5526_sdk\components\profiles\ams_c;..\..\..\platform\gr5526_sdk\components\profiles\ancs_c;..\..\..\platform\gr5526_sdk\components\profiles\ans;..\..\..\platform\gr5526_sdk\components\profiles\ans_c;..\..\..\platform\gr5526_sdk\components\profiles\bas;..\..\..\platform\gr5526_sdk\components\profiles\bas_c;..\..\..\platform\gr5526_sdk\components\profiles\bcs;..\..\..\platform\gr5526_sdk\components\profiles\bps;..\..\..\platform\gr5526_sdk\components\profiles\common;..\..\..\platform\gr5526_sdk\components\profiles\cscs;..\..\..\platform\gr5526_sdk\components\profiles\cts;..\..\..\platform\gr5526_sdk\components\profiles\cts_c;..\..\..\platform\gr5526_sdk\components\profiles\dis;..\..\..\platform\gr5526_sdk\components\profiles\dis_c;..\..\..\platform\gr5526_sdk\components\profiles\gls;..\..\..\platform\gr5526_sdk\components\profiles\gus;..\..\..\platform\gr5526_sdk\components\profiles\gus_c;..\..\..\platform\gr5526_sdk\components\profiles\hids;..\..\..\platform\gr5526_sdk\components\profiles\hrrcps;..\..\..\platform\gr5526_sdk\components\profiles\hrs;..\..\..\platform\gr5526_sdk\components\profiles\hrs_c;..\..\..\platform\gr5526_sdk\components\profiles\hts;..\..\..\platform\gr5526_sdk\components\profiles\ias;..\..\..\platform\gr5526_sdk\components\profiles\lls;..\..\..\platform\gr5526_sdk\components\profiles\lms;..\..\..\platform\gr5526_sdk\components\profiles\ndcs;..\..\..\platform\gr5526_sdk\components\profiles\otas;..\..\..\platform\gr5526_sdk\components\profiles\otas_c;..\..\..\platform\gr5526_sdk\components\profiles\pass;..\..\..\platform\gr5526_sdk\components\profiles\pass_c;..\..\..\platform\gr5526_sdk\components\profiles\pcs;..\..\..\platform\gr5526_sdk\components\profiles\rscs;..\..\..\platform\gr5526_sdk\components\profiles\rscs_c;..\..\..\platform\gr5526_sdk\components\profiles\rtus;..\..\..\platform\gr5526_sdk\components\profiles\sample;..\..\..\platform\gr5526_sdk\components\profiles\ths;..\..\..\platform\gr5526_sdk\components\profiles\ths_c;..\..\..\platform\gr5526_sdk\components\profiles\thscps;..\..\..\platform\gr5526_sdk\components\profiles\tps;..\..\..\platform\gr5526_sdk\components\profiles\wechat;..\..\..\platform\gr5526_sdk\components\sdk\;..\..\..\platform\gr5526_sdk\drivers\inc;..\..\..\platform\gr5526_sdk\drivers\inc\hal;..\..\..\platform\gr5526_sdk\external\freertos\include;..\..\..\platform\gr5526_sdk\external\freertos\portable\RVDS\ARM_CM4F;..\..\..\platform\gr5526_sdk\external\segger_rtt;..\..\..\platform\gr5526_sdk\platform\arch\arm\cortex-m\cmsis\core\include;..\..\..\platform\boards;..\..\..\platform\gr5526_sdk\platform\include;..\..\..\platform\gr5526_sdk\platform\soc\include;..\..\..\platform\gr5526_sdk\platform\soc\linker\keil
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x3000a000 size 0x36000
  scatter file: ..\..\..\platform\gr5526_sdk\platform\soc\linker\keil\flash_scatter_common.sct
  link misc: ..\..\..\platform\gr5526_sdk\platform\soc\linker\keil\rom_symbol.txt
  group gr_startup
    ../../../platform/gr5526_sdk/platform/arch/arm/cortex-m/keil/: Startup.S
  group gr_arch
    ../../../platform/gr5526_sdk/platform/soc/common/: gr_interrupt.c gr_platform.c gr_system.c
  group gr_soc
    ../../../platform/gr5526_sdk/platform/soc/src/: gr_soc.c
  group gr_board
    ../../../platform/boards/: board_SK.c
  group gr_stack_lib
    ../../../platform/gr5526_sdk/platform/soc/linker/keil/: ble_sdk.lib
  group gr_app_drivers
    ../../../platform/gr5526_sdk/drivers/src/: app_dma.c app_gpiote.c app_io.c app_pwr_mgmt.c app_uart.c app_rtos_cfg.c app_uart_dma.c app_rtc.c
  group gr_libraries
    ../../../platform/gr5526_sdk/components/libraries/utility/: utility.c
    ../../../platform/gr5526_sdk/components/libraries/app_timer/: app_timer.c
    ../../../platform/gr5526_sdk/components/libraries/ring_buffer/: ring_buffer.c
    ../../../platform/gr5526_sdk/components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../platform/gr5526_sdk/components/libraries/app_log/: app_log.c app_log_dump_port.c app_log_store.c
    ../../../platform/gr5526_sdk/components/libraries/app_error/: app_error.c
    ../../../platform/gr5526_sdk/components/libraries/app_assert/: app_assert.c
    ../../../platform/gr5526_sdk/components/libraries/app_key/: app_key.c app_key_core.c
    ../../../platform/gr5526_sdk/components/libraries/ble/ble_time/: ble_time.c
    ../../../platform/gr5526_sdk/components/libraries/dfu_port/: dfu_port.c
    ../../../platform/gr5526_sdk/components/sdk/: ble.c
  group gr_profiles
    ../../../platform/gr5526_sdk/components/profiles/common/: ble_prf_utils.c
    ../../../platform/gr5526_sdk/components/profiles/otas/: otas.c
    ../../../platform/gr5526_sdk/components/profiles/lms/: lms.c
  group external
    ../../../platform/gr5526_sdk/external/freertos/portable/GR55XX/: port_pm.c
    ../../../platform/gr5526_sdk/external/freertos/portable/RVDS/ARM_CM4F/: port.c
    ../../../platform/gr5526_sdk/external/freertos/: timers.c tasks.c stream_buffer.c queue.c list.c heap_4.c event_groups.c croutine.c
    ../../../platform/gr5526_sdk/external/segger_rtt/: SEGGER_RTT.c
  group user_platform
    ../Src/platform/: user_periph_setup.c
  group user_app
    ../Src/user/: main.c user_app.c FreeRTOSConfig.h
    ./../Src/config/: custom_config.h
